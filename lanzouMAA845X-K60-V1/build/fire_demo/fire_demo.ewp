# IAR project fire_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\app; ..\..\src\app\nokia; ..\..\src\app\calculation; ..\..\src\app\ccd; ..\..\src\app\isr; ..\..\src\app\main; ..\..\src\common; ..\..\src\common\alloc; ..\..\src\common\assert; ..\..\src\common\io; ..\..\src\common\printf; ..\..\src\common\queue; ..\..\src\common\startup; ..\..\src\common\stdlib; ..\..\src\common\uif; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\cpu\headers\MK60DZ10; ..\..\src\cpu\headers\common; ..\..\src\cpu\headers\fier_drivers_cfg; ..\..\src\cpu\headers\include; ..\..\src\cpu\headers\ish; ..\..\src\cpu\headers\k60_fire; ..\..\src\cpu\vectors; ..\..\src\cpu\sysinit; ..\..\src\cpu\start; ..\..\src\cpu\arm_cm4; ..\..\src\cpu\crt0; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\delay; ..\..\src\drivers\dma; ..\..\src\drivers\exti; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\queue; ..\..\src\LIB; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\src\uCOS-II; ..\..\src\uCOS-II\Ports; ..\..\src\uCOS-II\Source; ..\..\src\uCOS-II\App; ..\..\src\uCOS-II\App\CFG; ..\..\build
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCOptLevel: 3
  group app
    ../../src/app/: calculation.c isr.c main.c nokia.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c MOTOR.c power_display.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/AT24C02/: AT24C02.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h power_display.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/app/: include.h isr.h
    ../../src/platforms/: k60_fire.h
